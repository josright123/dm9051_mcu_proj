# Keil uVision project x2web_project.uvprojx, settings and files
target x2web (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: AT32F413RC ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: x2web +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: AT32F413RCT7,USE_STDPERIPH_DRIVER,AT_START_F413_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\middlewares\3rd_party\lwip_2.1.2\port\arch;..\..\middlewares\3rd_party\lwip_2.1.2\src\include\lwip;..\..\middlewares\3rd_party\lwip_2.1.2\src\apps\ping;..\..\lwip1_v212\middlewares\3rd_party\lwip_2.1.2\src\include;..\..\..\dm9051_lw;..\..\lwip1_v212;..\..\lwip1_v212\port_ethernetif2311v1\Standalone;..\..\lwip1_v212\middlewares\3rd_party\lwip_2.1.2\src\apps\http;..\src;..\..\..\..\at32f413_board
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../src/: main.c proc_main.c netconf - basic.c netconf_b.c developer_conf.c LOG.c tmr_init.c at32f413_int.c at32f413_clock.c
    ../../lwip1_v212/: lwip_initialize.c stack_init.c
    ../../lwip1_v212/port_ethernetif2311v1/Standalone/: sys_arch.c ethernetif.c
    ../../lwip1_v212/lwip_web2310v1/: httpd.c fs_jjdynamic.c
    ../: netifo.c head.c
  group bsp
    ../../../../at32f413_board/: at32f413_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f413_crm.c at32f413_usart.c at32f413_gpio.c at32f413_misc.c at32f413_spi.c at32f413_tmr.c at32f413_exint.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f413.c
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f413.s
  group lwip
    ../../lwip1_v212/middlewares/3rd_party/lwip_2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../lwip1_v212/middlewares/3rd_party/lwip_2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../lwip1_v212/middlewares/3rd_party/lwip_2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../lwip1_v212/middlewares/3rd_party/lwip_2.1.2/src/netif/: ethernet.c
  group readme
    ../: readme.txt
    ../../../dm9051_lw/: info.txt
  group dm9051_lw
    ../../../dm9051_lw/: dm9051_lw_conf.c dm9051_lw.c dm9051_lw_log.c dm9051opts.c
